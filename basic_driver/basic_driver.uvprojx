# Keil uVision project basic_driver.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: basic_driver
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\basic_driver\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group app
    ./app/: app.c app.h
  group btn
    ./btn/: btn.c btn.h
  group led
    ./led/: led.c led.h
  group sys
    ./sys/: sys.c sys.h
  group systick
    ./systick/: systick.c systick.h
  group uart
    ./uart/: uart.c uart.h
  group ds
    ./ds/: ds.c ds.h
  group generic
    ./generic/: generic.c generic.h
  group interrupt
    ./interrupt/: interrupt.c interrupt.h
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.1
